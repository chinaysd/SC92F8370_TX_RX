# Keil uVision project FullResources.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F7323 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(24000000)
  output: FullResources +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./c/: IO_Init.c main.c SSI_Init.c
